<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LCD_PWM_LED_CDS.ewp</path>
  </project>
  <batchBuild />
</workspace>
