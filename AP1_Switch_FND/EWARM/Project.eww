<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\AP1_Switch_FND.ewp</path>
  </project>
  <batchBuild />
</workspace>
