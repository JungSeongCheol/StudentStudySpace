<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Ex1_Reverse_Front.ewp</path>
  </project>
  <batchBuild />
</workspace>
