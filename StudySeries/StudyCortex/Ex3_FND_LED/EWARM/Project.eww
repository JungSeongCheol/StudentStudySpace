<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Ex3_FND_LED.ewp</path>
  </project>
  <batchBuild />
</workspace>
