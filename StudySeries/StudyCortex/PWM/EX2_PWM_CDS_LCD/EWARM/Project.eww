<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\EX2_PWM_CDS_LCD.ewp</path>
  </project>
  <batchBuild />
</workspace>
