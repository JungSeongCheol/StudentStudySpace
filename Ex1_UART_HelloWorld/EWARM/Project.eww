<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Ex1_UART_HelloWorld.ewp</path>
  </project>
  <batchBuild />
</workspace>
