<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\EX1_USART_Hello.ewp</path>
  </project>
  <batchBuild />
</workspace>
