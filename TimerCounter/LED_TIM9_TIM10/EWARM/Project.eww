<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LED_TIM9_TIM10.ewp</path>
  </project>
  <batchBuild />
</workspace>
